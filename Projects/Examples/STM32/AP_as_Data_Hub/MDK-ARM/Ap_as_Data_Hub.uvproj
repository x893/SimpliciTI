# Keil uVision project Ap_as_Data_Hub.uvproj, settings and files
target CC1101-Access Point (ARM-ADS)
  device: STM32F100RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Ap_as_Data_Hub
  c flags: Optim=1 OneElfS=1
  c define: MRFI_CC1101 CFG_ACCESS_POINT
  c include: .\;..\..\..\..\..\Components\bsp;..\..\..\..\..\Components\bsp\drivers;..\..\..\..\..\Components\bsp\boards\STM32;..\..\..\..\..\Components\mrfi;..\..\..\..\..\Components\simpliciti\nwk;..\..\..\..\..\Components\simpliciti\nwk_applications;..\..\..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\..\..\Libraries\CMSIS\CM3\DeviceSupport;..\..\..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group application
    ../../../Applications/: main_AP_Async_Listen_autoack.c main_manyEDs_autoack.c main_AP_RE.c main_ED_Sniffer.c
  group bsp
    ../../../../../Components/bsp/: bsp.c
    ../../../../../Components/bsp/boards/STM32/: bsp_board_defs.h bsp_button_defs.h bsp_config.h bsp_driver_defs.h bsp_led_defs.h
  group mrfi
    ../../../../../Components/bsp/boards/STM32/bsp_external/: mrfi_board_defs.h
    ../../../../../Components/mrfi/: mrfi.c
  group nwk
    ../../../../../Components/simpliciti/nwk/: nwk.c nwk_api.c nwk_frame.c nwk_globals.c nwk_QMgmt.c
  group nwk_applications
    ../../../../../Components/simpliciti/nwk_applications/: nwk_freq.c nwk_ioctl.c nwk_join.c nwk_link.c nwk_mgmt.c nwk_ping.c nwk_pll.c nwk_security.c
  group STM32
    ../../../../../Components/bsp/boards/STM32/: startup_stm32f10x_md_vl.s system_stm32f10x.c stm32f10x.h stm32f10x_conf.h
  group STM32F10x_StdPeriph
    ../../../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c
target CC1101-End Device (ARM-ADS)
  device: STM32F100RB STMicroelectronics
  cpu: as above
  output: Ap_as_Data_Hub
  c flags: Optim=1 OneElfS=1
  c define: MRFI_CC1101 CFG_END_DEVICE
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
target CC1101-Range Extender (ARM-ADS)
  device: STM32F100RB STMicroelectronics
  cpu: as above
  output: Ap_as_Data_Hub
  c flags: Optim=1 OneElfS=1
  c define: MRFI_CC1101 CFG_RANGE_EXTENDER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
target CC1101-Channel Sniffer (ARM-ADS)
  device: STM32F100RB STMicroelectronics
  cpu: as above
  output: Ap_as_Data_Hub
  c flags: Optim=1 OneElfS=1
  c define: MRFI_CC1101 CFG_CHANNEL_SNIFFER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
